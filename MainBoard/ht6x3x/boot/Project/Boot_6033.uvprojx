# Keil uVision project Boot_6033.uvprojx, settings and files
target bootLoader (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Boot_6033 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HT6x2x
  c include: ..\Main;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\Startup;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ../Main/: CpuCfg.c ht60xx_it.c main.c update.c
  group Driver
    ../Driver/: cmu.c FIFO.c flash.c gpio.c lcd.c systick.c usart.c
  group CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm0.c
    ../Libraries/CMSIS/DeviceSupport/: system_ht6xxx.c
  group Statup
    ../Libraries/Startup/: startup_ht6x3x.s
