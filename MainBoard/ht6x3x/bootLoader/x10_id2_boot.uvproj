# Keil uVision project x10_id2_boot.uvproj, settings and files
target x10_id2_boot (5060020::V5.06 (build 20)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: x10_id2_boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HT6x2x
  c include: .\Main;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\CoreSupport;.\Libraries\Startup;.\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fff
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./Main/: main.c update.c CpuCfg.c ht60xx_it.c include.h CpuCfg.h
  group Driver
    ./Driver/: cmu.c FIFO.c gpio.c systick.c lcd.c flash.c usart.c
  group CMSIS
    ./Libraries/CMSIS/CoreSupport/: core_cm0.c
    ./Libraries/CMSIS/DeviceSupport/: system_ht6xxx.c
  group Startup
    ./Libraries/Startup/: startup_ht6x2x.s
