# Keil uVision project X10P.uvprojx, settings and files
target X10P (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: X10P +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HT6x3x
  c include: ..\Main;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\Startup;..\freertos\include;..\freertos\portable\Keil\ARM_CM0;..\freertos\portable\MemMang;..\freertos\portable\RVDS;..\Driver;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x37000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Main
    ../Main/: CpuCfg.c main.c
  group App
    ../App/: blueProto.c card.c emu.c gun.c history_order.c outNetProto.c productTest.c proto.c server.c sim800c.c tfs.c ui.c upgrade.c relayCtrlTask.c
  group Drive
    ../Driver/: aes.c cmu.c FIFO.c flash.c gpio.c i2c.c lcd.c md5.c ntcad.c rtc.c sc8042.c simuart.c systick.c usart.c TempDetection.c
  group CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm0.c
    ../Libraries/CMSIS/DeviceSupport/: system_ht6xxx.c
  group Startup
    ../Libraries/Startup/: startup_ht6x3x.s
  group FreeRTOS
    ../freertos/: list.c queue.c tasks.c
    ../freertos/portable/Keil/ARM_CM0/: port.c
    ../freertos/portable/MemMang/: heap_4.c
