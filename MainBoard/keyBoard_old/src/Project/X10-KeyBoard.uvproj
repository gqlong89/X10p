# Keil uVision project X10-KeyBoard.uvproj, settings and files
target CA51FX (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: X10-KeyBoard +hex
  AfterMake: make_bin.bat
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\Src;..\Drivers\Includes;..\Drivers\Conf;..\Drivers\Sources
  link misc: REMOVEUNUSED
  group ca51f_config
    ../Src/: ca51f_config.h
  group Source Files
    ../Src/: main.c fm175xx.c type_a.c key.c ca51f2xx_it.c bluetooth.c fifo.c MainHandle.c proto.c
  group Drivers
    ../Drivers/Sources/: delay.c system_clock.c uart.c rtc.c spi.c wdt.c ts_api.c ts_sevice.c blue_api.c
  group Startup
    ../Drivers/Lib/: STARTUP.A51
  group README
    ../: README.md
